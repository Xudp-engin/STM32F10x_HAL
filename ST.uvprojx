# Keil uVision project ST.uvprojx, settings and files
target STM32F103 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: ST +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\StdPeriph\inc;.\CMSIS;.\App;.\CommonLib;.\DevWrapper;.\Hal
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group App
    ./App/: stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c retarget.c serial.c main.cpp
  group CommonLib
    ./CommonLib/: CommonProtocol.c CommonString.c CommonUtil.c
  group Hal
    ./Hal/: EEPROM.cpp SPIFlash.cpp
  group DevWrapper
    ./DevWrapper/: DevWrapperCAN.c DevWrapperIO.c DevWrapperIIC.c systick.c DevWrapperSPI.c
  group StdPeriph
    ./StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_cec.c
